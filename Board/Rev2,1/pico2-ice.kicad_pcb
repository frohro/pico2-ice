# Repository frohro/pico2-ice

## KiCad design Board/Rev2,1/pico2-ice.kicad_pcb

Parts:
C1, C2: 10p; C_0402_1005Metric; MPN GRM1555C1E100JA01D; LCSC C32949
C3, C6, C7, C11, C13, C20, C22, C23, C25, C30, C31, C32, C34, C35, C37, C38, C39, C41: 4.7u; C_0402_1005Metric; MPN GRM155R60J475ME87D; LCSC C23733
C4, C5, C8, C9, C10, C12, C14, C15, C16, C17, C18, C19, C21, C24, C26, C27, C28, C29, C33, C36, C40, C42: 0.1u; C_0402_1005Metric; MPN GRM155R71C104KA88J; LCSC C1525
D1: 1N4148WT-7; D_SOD-523; MPN 1N4148WT-7; LCSC C27748
D2, D4: MHPA1010RGBDT; LED_Cree-PLCC4_1x1mm_CW; MPN MHPA1010RGBDT; Digi-Key Part Number LCSC
D3: LTST-C191KGKT; LED_0603_1608Metric; MPN LTST-C191KGKT; LCSC C125098
D5, D6, D7: 1N5819WS; D_SOD-323; MPN 1N5819WS; LCSC C191023
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial; Fiducial_0.75mm_Mask1.5mm; MPN DNP; not fitted
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5; MPN DNP; not fitted
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN USB4105-GF-A; LCSC C2765186
J2: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Vertical_Left; MPN DNP; not fitted
J3: Conn_02x20_Odd_Even; PinHeader_2x20_P2.54mm_Vertical_Right; MPN DNP; not fitted
J5: BM03B-SRSS-TB; JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical; MPN BM03B-SRSS-TB; LCSC C160389
J6: SFV22R-2STE1HLF; AMPHENOL_SFV22R-2STE1HLF; MPN SFV22R-2STE1HLF; LCSC C5373438
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
L1: 3.3u; L_pol_2016; MPN MLP2016H3R3MT0S1 (substituted AOTA-B201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; LCSC C42411119
LOGO2: WEEE Logo; WEEE logo; MPN DNP; Digi-Key_PN DNP; not fitted
LOGO4: OSHW ID: US002372; OSHW_Dual_0.1_Scale_2140; MPN DNP; Digi-Key_PN DNP; not fitted
PTC1: MF-FSMF035X-2; R_0603_1608Metric; MPN MF-FSMF035X-2; LCSC C116602
R1, R2, R17, R18, R19: 1k; R_0402_1005Metric; MPN RC0402FR-071KL; LCSC C11702
R3, R27: DNF; R_0402_1005Metric; not fitted
R4, R5, R6, R9, R26, R34: 22; R_0402_1005Metric; MPN RC0402FR-0727RL; LCSC C25092
R7, R13, R15, R23, R28, R32: 10K; R_0402_1005Metric; LCSC C25744
R8, R16, R21: 10K; R_0402_1005Metric; MPN RC0402FR-0710KL; LCSC C25744
R10, R24, R33: 5.1K; R_0402_1005Metric; MPN RC0402FR-075K1L; LCSC C25905
R11, R25: 100; R_0402_1005Metric; MPN RC0402FR-07100RL; LCSC C25076
R12: 1K; R_0402_1005Metric; MPN RC0402FR-071KL; LCSC C11702
R14: 2.2K; R_0402_1005Metric; MPN RC0402FR-072K2L; LCSC C25879
R20: 51K; R_0402_1005Metric; MPN RC0402FR-0756KL; LCSC C25794
R22: 51k; R_0402_1005Metric; MPN RC0402FR-0756KL; LCSC C25794
R29: 2.2K; R_0402_1005Metric; LCSC C25879
R30, R31: SHORT; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; MPN DNP
RN1: 10K; R_Array_Concave_4x0402; MPN YC124-FR-0710KL; LCSC C136853
SJ1, SJ2, SJ3, SJ4, SJ5, SJ6: SHORT; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; MPN DNP
SW1, SW2: CS1213AGF260; PTS820J25KSMTRLFS; MPN CS1213AGF260; LCSC C720477
U1: NCP115AMX120TCG; OnSemi_XDFN4-1EP_1.0x1.0mm_EP0.52x0.52mm; MPN NCP115AMX120TCG; LCSC C603500
U2, U8: W25Q32JVSSIQ; SOIC-8_5.23x5.23mm_P1.27mm; MPN W25Q32JVSSIQ; LCSC C82344
U3: RP2350_80QFN; RP2350B_QFN-80_EP_10.573x10.573_Pitch0.4mm; MPN RP2350B; LCSC C42415655
U4: TL431DBZ; SOT-23; MPN TL431BQDBZR; LCSC C190245
U5: APS6404L-3SQN-SN (substituted APS6404L-3SQR-ZR ha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; Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm; MPN APS6404L-3SQN-SN; LCSC C3040877
U6: ICE40UP5K-SG48ITR; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm; MPN ICE40UP5K-SG48I; LCSC C2678152
U9: NCP115AMX330TCG; OnSemi_XDFN4-1EP_1.0x1.0mm_EP0.52x0.52mm; MPN NCP115AMX330TCG; LCSC C892047
Y1: ABM8-272-T3; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN ABM8-272-T3; LCSC C20625731

Connections:
+1V1: C4.1, C5.1, C6.1, C38.1, L1.1, U3.10 (DVDD), U3.32 (DVDD), U3.51 (DVDD), U3.65 (VREG_FB)
+1V2: C37.1, R11.2, SJ4.2, U1.1 (OUT)
+3V3: C8.1, C10.1, C11.1, C12.1, C15.1, C16.1, C17.1, C18.1, C19.1, C41.1, C42.1, D7.1 (K), J3.33, J3.34, J6.22, R3.1, R13.1, R15.1, R16.2, R23.1, R25.2, R26.2, R32.1, SJ1.2, SJ6.2, U2.8 (VCC), U3.5 (IOVDD), U3.15 (IOVDD), U3.24 (IOVDD), U3.29 (IOVDD), U3.41 (IOVDD), U3.50 (IOVDD), U3.60 (IOVDD), U3.68 (USB_OTP_VDD), U3.69 (QSPI_IOVDD), U3.76 (IOVDD), U5.8 (VCC), U9.1 (OUT)
+3V3_FPGA: C7.1, C21.1, C22.1, C24.1, C25.1, C26.1, C28.1, D1.2 (A), J2.5, J2.6, J3.15, J3.16, R8.2, R14.2, R21.1, SJ2.2, SJ5.1, SJ6.1, U1.3 (EN), U1.4 (IN), U6.22 (SPI_VCCIO1), U6.33 (VCCIO_0), U8.8 (VCC)
/+1.2V_CORE: C27.1, C40.1, SJ4.1, U6.5 (VCC), U6.30 (VCC)
/ADC1: J3.19, U3.52 (GPIO41_ADC1)
/ADC2|PB: J3.21, R33.2, U3.53 (GPIO42_ADC2)
/ADC3: J3.37, U3.54 (GPIO43_ADC3)
/ADC4: J3.38, U3.55 (GPIO44_ADC4)
/ADC5|VREF: J3.39, R30.2, U3.56 (GPIO45_ADC5)
/ADC6: J3.40, R31.2, U3.57 (GPIO46_ADC6)
/ADC7: J2.39, R29.1
/Clock_N: J6.8, U3.16 (GPIO16)
/Clock_P: J6.9, U3.17 (GPIO17)
/GPIO10: J6.14, U3.8 (GPIO10)
/GPIO11: J6.15, U3.9 (GPIO11)
/ICE_2: J2.32, U6.2 (IOB_6a)
/ICE_3: J2.33, U6.3 (IOB_9b)
/ICE_4: J2.34, U6.4 (IOB_8a)
/ICE_6: J2.20, U6.6 (IOB_13b)
/ICE_9: J2.22, U3.36 (GPIO28), U6.9 (IOB_16a)
/ICE_10|PB: C14.1, J2.21, R21.2, SW2.2, U6.10 (IOB_18a)
/ICE_11: J2.19, U3.37 (GPIO29), U6.11 (IOB_20a)
/ICE_12|IO2: J2.1, RN1.6 (R3.2), U6.12 (IOB_22a), U8.3 (IO2)
/ICE_13|IO3: J2.3, RN1.5 (R4.2), U6.13 (IOB_24a), U8.7 (IO3)
/ICE_18: J3.8, U3.28 (GPIO27), U6.18 (IOB_31b)
/ICE_19: J3.7, J6.18, U3.23 (GPIO23), U6.19 (IOB_29b)
/ICE_20_G3: J3.12, R34.1, U6.20 (IOB_25b_G3)
/ICE_21: J3.11, U3.27 (GPIO26), U6.21 (IOB_23b)
/ICE_23: J3.6, U3.26 (GPIO25), U6.23 (IOT_37a)
/ICE_25: J3.5, U3.38 (GPIO30), U6.25 (IOT_36b)
/ICE_26: J3.10, U3.25 (GPIO24), U6.26 (IOT_39a)
/ICE_27: J3.9, J6.17, U3.20 (GPIO20), U6.27 (IOT_38b)
/ICE_28: J2.9, U6.28 (IOT_41a)
/ICE_31: J2.10, U6.31 (IOT_42b)
/ICE_32: J2.11, U6.32 (IOT_43a)
/ICE_34: J2.12, U6.34 (IOT_44b)
/ICE_35_G0: J2.18, R6.1, U6.35 (IOT_46b_G0)
/ICE_36: J2.13, U6.36 (IOT_48b)
/ICE_37: J2.17, U6.37 (IOT_45a_G1)
/ICE_38: J2.14, U6.38 (IOT_50b)
/ICE_42: J2.15, U6.42 (IOT_51a)
/ICE_43: J2.16, U6.43 (IOT_49a)
/ICE_44_G6: J2.31, U6.44 (IOB_3b_G6)
/ICE_45: J2.30, U6.45 (IOB_5b)
/ICE_46: J2.29, U6.46 (IOB_0a)
/ICE_47: J2.28, U6.47 (IOB_2a)
/ICE_48: J2.27, U6.48 (IOB_4a)
/ICE_DONE|ADC0: D3.2 (A), J3.17, R14.1, SJ3.1, U3.49 (GPIO40_ADC0)
/ICE_LED_B: D4.4 (BK), J3.22, U6.40 (RGB1)
/ICE_LED_G: D4.3 (GK), J3.20, U6.39 (RGB0)
/ICE_LED_R: D4.2 (RK), J3.18, U6.41 (RGB2)
/ICE_SCK: J3.4, R9.1, RN1.7 (R2.2), U6.15 (IOB_34a_SPI_SCK), U8.6 (CLK)
/ICE_SI: J3.3, RN1.8 (R1.2), U3.1 (GPIO4), U6.17 (IOB_33b_SPI_SI), U8.2 (DO(IO1))
/ICE_SO: J3.2, U3.4 (GPIO7), U6.14 (IOB_32a_SPI_SO), U8.5 (DI(IO0))
/ICE_SSN: J3.1, R8.1, U3.2 (GPIO5), U6.16 (IOB_35b_SPI_SS), U8.1 (~CS)
/LED_B: R19.1, U3.7 (GPIO9)
/LED_G: R18.1, U3.77 (GPIO0)
/LED_R: R17.1, U3.78 (GPIO1)
/Lane0_N: J6.2, U3.11 (GPIO12)
/Lane0_P: J6.3, U3.12 (GPIO13)
/Lane1_N: J6.5, U3.13 (GPIO14)
/Lane1_P: J6.6, U3.14 (GPIO15)
/Lane2_N: J6.11, U3.18 (GPIO18)
/Lane2_P: J6.12, U3.19 (GPIO19)
/PICO_PMOD_A1: J3.23, U3.42 (GPIO33)
/PICO_PMOD_A2: J3.25, U3.44 (GPIO35)
/PICO_PMOD_A3: J3.27, U3.40 (GPIO32)
/PICO_PMOD_A4: J3.29, U3.43 (GPIO34)
/PICO_PMOD_B1: J3.24, U3.46 (GPIO37)
/PICO_PMOD_B2: J3.26, U3.48 (GPIO39)
/PICO_PMOD_B3: J3.28, U3.45 (GPIO36)
/PICO_PMOD_B4: J3.30, U3.47 (GPIO38)
/QSPI_SCLK: U2.6 (CLK), U3.71 (QSPI_SCLK), U5.6 (CLK)
/QSPI_SD0: U2.5 (DI(IO0)), U3.72 (QSPI_SD0), U5.5 (DI(IO0))
/QSPI_SD1: U2.2 (DO(IO1)), U3.74 (QSPI_SD1), U5.2 (DO(IO1))
/QSPI_SD2: U2.3 (IO2), U3.73 (QSPI_SD2), U5.3 (IO2)
/QSPI_SD3: U2.7 (IO3), U3.70 (QSPI_SD3), U5.7 (IO3)
/SCL_GPIO3: J2.37, J6.20, R23.2, U3.80 (GPIO3)
/SDA_GPIO2: J2.35, J6.21, R13.2, U3.79 (GPIO2)
/SWCLK: J5.1, U3.33 (SWCLK)
/SWD: J5.3, U3.34 (SWD)
/USB_D+: J1.A6 (D+), J1.B6 (D+), R4.1
/USB_D-: J1.A7 (D-), J1.B7 (D-), R5.1
/USB_N: R5.2, U3.66 (USB_DM)
/USB_P: R4.2, U3.67 (USB_DP)
/VCC_PLL: C33.1, C34.1, R11.1, U6.29 (VCCPLL)
/VIO_BANK_2: C29.1, C30.1, J2.23, J2.24, SJ5.2, U6.1 (VCCIO_2)
/VREG_AVDD: C23.1, R26.1, U3.61 (VREG_AVDD)
/VREG_LX: L1.2, U3.63 (VREG_LX)
/XIN: C2.1, U3.30 (XIN), Y1.1
/XOUT: R1.1, U3.31 (XOUT)
/~ICE_RST: J2.2, R7.1, U3.39 (GPIO31), U6.8 (~CRESET)
/~QSPI_SS: R2.1, R3.2, R27.1, U2.1 (~CS), U3.75 (QSPI_SS)
/~RESET: J2.36, R16.1, U3.35 (RUN)
/~SRAM_SS: R15.2, R27.2, U3.6 (GPIO8), U5.1 (~CS)
/~USB_BOOT: D6.1 (K), J2.38, R32.2, R33.1, SW1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, D3.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, J2.7, J2.8, J2.25, J2.26, J2.40, J3.13, J3.14, J3.31, J3.32, J5.2, J5.MP (MountPin), J6.1, J6.4, J6.7, J6.10, J6.13, J6.16, J6.19, J6.MP (MountPin), R7.2, R10.2, R24.2, R28.2, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), SW1.1, SW1.SH1, SW1.SH2, SW2.1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
unnamed: C1.1, R1.2, Y1.3
unnamed: C31.1, D1.1 (K), U6.24 (VPP_2V5)
unnamed: C32.1, D2.1 (A), SJ1.1
unnamed: D2.4 (BK), R19.2
unnamed: D2.3 (GK), R18.2
unnamed: D2.2 (RK), R17.2
unnamed: C13.1, D4.1 (A), SJ2.1
unnamed: D5.1 (K), PTC1.2
unnamed: D6.2 (A), R2.2
unnamed: D7.2 (A), R28.1, R29.2, U3.58 (GPIO47_ADC7)
unnamed: J1.A5 (CC1), JP2.2 (C)
unnamed: J1.B5 (CC2), JP1.2 (C)
unnamed: JP1.1 (A), R24.1
unnamed: JP1.3 (B), R20.2
unnamed: JP2.1 (A), R10.1
unnamed: JP2.3 (B), R22.2
unnamed: R12.1, R31.1
unnamed: C9.1, C35.1, R25.1, U3.59 (ADC_AVDD)
unnamed: R9.2, U3.3 (GPIO6)
unnamed: R6.2, U3.21 (GPIO21)
unnamed: R34.2, U3.22 (GPIO22)
unnamed: C36.1, R12.2, R30.1, U4.1 (K), U4.2 (REF)
unnamed: SJ3.2, U6.7 (CDONE)
V_{BUS}: D5.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J3.35, R20.1, R22.1
V_{in}: C3.1, C20.1, C39.1, J3.36, PTC1.1, U3.64 (VREG_VIN), U9.3 (EN), U9.4 (IN)

Notes on the sheet:
SCK1
MOSI1
FPGA LED
GPIO
SRAM
iCE PMOD
FPGA 1.2V Core
SCK0
Place R4/R5 close to RP2040
GPIO18
Pico PMOD
SSn1
SSn
SCK
Note: Output-only when the pll is used for 2 output mode
GPIO14
MOSI0
HSTX FPC Connector
MISO1
Bank 1 is 3.3V IO!
FPGA Power
Bank 2
https://datasheets.raspberrypi.com/rp2350/hardware-design-with-rp2350.pdf
CSn0
USBC Connector
iCE Misc
GPIO15
MISO0
GPIO17
The button functions as a boot select as well as GPIO.
FPGA Button
Peripheral Headers
LED/ADC
GPIO16
Suggested data clock
RP2 LED
ADC/Power
Note: Bank 2 is selectable IO voltage! To select non-3.3V, cut the shorted jumper and supply external voltage (1.8-3.3V) on VIO_BANK_2.
Note: Set the GPIO high to enable power to the reference when the ADC needs to be calibrated. Remove resistors to use the ADC on the external pins.
JST Debug Connector

Board: 4 copper layers, 27.9 x 63.5 mm, 122 parts (67 on the bottom side), 123 nets.

File Board/Rev2,1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0402,2,10p,C32949
"C10, C12, C14, C15, C16, C17, C18, C19, C21, C24, C26, C27, C28, C29, C33, C36, C4, C40, C42, C5, C8, C9",0402,22,0.1u,C1525
"C11, C13, C20, C22, C23, C25, C3, C30, C31, C32, C34, C35, C37, C38, C39, C41, C6, C7",0402,18,4.7u,C23733
D1,D_SOD-523,1,1N4148WT-7,C27748
"D2, D4",LED_Cree-PLCC4_1x1mm_CW,2,MHPA1010RGBDT,C404280
D3,0603,1,LTST-C191KGKT,C125098
"D5, D6, D7",D_SOD-323,3,1N5819WS,C191023
"FID1, FID2, FID3, FID4, FID5, FID6",Fiducial_0.75mm_Mask1.5mm,6,Fiducial,DNP
"H1, H2, H3, H4",MountingHole_2.7mm_M2.5,4,MountingHole,DNP
J1,USB_C_Receptacle_HRO_TYPE-C-31-M-12,1,USB_C_Receptacle_USB2.0,C2765186
J2,PinHeader_2x20_P2.54mm_Vertical_Left,1,Conn_02x20_Odd_Even,DNP
J3,PinHeader_2x20_P2.54mm_Vertical_Right,1,Conn_02x20_Odd_Even,DNP
J5,JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical,1,BM03B-SRSS-TB,C160389
J6,AMPHENOL_SFV22R-2STE1HLF,1,SFV22R-2STE1HLF,C5373438
L1,L_pol_2016,1,3.3u,C42411119
PTC1,0603,1,MF-FSMF035X-2,C116602
"R1, R12, R17, R18, R19, R2",0402,6,1k,C11702
"R10, R24, R33",0402,3,5.1K,C25905
"R11, R25",0402,2,100,C25076
"R13, R15, R16, R21, R23, R28, R32, R7, R8",0402,9,10K,C25744
"R14, R29",0402,2,2.2K,C25879
"R20, R22",0402,2,51K,C25794
"R26, R34, R4, R5, R6, R9",0402,6,22,C25092
R27,0402,1,DNF,
"R30, R31, SJ1, SJ2, SJ3, SJ4, SJ5, SJ6",SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm,8,SHORT,DNP
RN1,R_Array_Concave_4x0402,1,10K,C136853
"SW1, SW2",PTS820J25KSMTRLFS,2,CS1213AGF260,C720477
U1,OnSemi_XDFN4-1EP_1.0x1.0mm_EP0.52x0.52mm,1,NCP115AMX120TCG,C603500
"U2, U8",SOIC-8_5.23x5.23mm_P1.27mm,2,W25Q32JVSSIQ,C82344
U3,RP2350B_QFN-80_EP_10.573x10.573_Pitch0.4mm,1,RP2350_80QFN,C42415655
U4,SOT-23,1,TL431DBZ,C190245
U5,Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm,1,APS6404L-3SQN-SN (substituted  APS6404L-3SQR-ZR have to change package too),C3040877
U6,QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm,1,ICE40UP5K-SG48ITR,C2678152
U9,OnSemi_XDFN4-1EP_1.0x1.0mm_EP0.52x0.52mm,1,NCP115AMX330TCG,C892047
Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,ABM8-272-T3,C20625731

## Commit log

2025-08-23 WWU Board JLCPCB Order
2025-08-24 Removed the WWU_ on the Rev2,1 directory, because it was redundant
2025-09-08 No changes detected
2025-09-09 Fixed U2 getting flipped on schematic
